<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("F")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_GAUSSIAN</value></param>
<param><key>mean</key><value>150</value></param>
<param><key>msg</key><value>pmt.intern("E")</value></param>
<param><key>std</key><value>50</value></param>
</block>
<block>
<key>lora_sdr_err_measures</key>
<param><key>id</key><value>lora_sdr_err_measures_0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>nao usar message debug aqui</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>strobe</source_key><sink_key>ref</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_err_measures_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>err</source_key><sink_key>print</sink_key></connection>
</flow_graph>

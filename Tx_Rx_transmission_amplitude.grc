<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_RX</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cr</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pay_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>0.01</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_imag</key>
<param><key>id</key><value>blocks_complex_to_imag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("Hello world")</value></param>
<param><key>period</key><value>2000</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value>-0.128616616593872,	-0.212206590789194,	-0.180063263231421,	3.89817183251938e-17	,0.300105438719035	,0.636619772367581	,0.900316316157106,	1	,0.900316316157106,	0.636619772367581,	0.300105438719035,	3.89817183251938e-17,	-0.180063263231421,	-0.212206590789194,	-0.128616616593872</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lora_sdr_add_crc</key>
<param><key>id</key><value>lora_sdr_add_crc_0</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
</block>
<block>
<key>lora_sdr_crc_verif</key>
<param><key>id</key><value>lora_sdr_crc_verif_0</value></param>
</block>
<block>
<key>lora_sdr_deinterleaver</key>
<param><key>id</key><value>lora_sdr_deinterleaver_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_dewhitening</key>
<param><key>id</key><value>lora_sdr_dewhitening_0</value></param>
</block>
<block>
<key>lora_sdr_err_measures</key>
<param><key>id</key><value>lora_sdr_err_measures_0</value></param>
</block>
<block>
<key>lora_sdr_fft_demod</key>
<param><key>id</key><value>lora_sdr_fft_demod_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_frame_sync</key>
<param><key>id</key><value>lora_sdr_frame_sync_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_gray_decode</key>
<param><key>id</key><value>lora_sdr_gray_decode_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_gray_enc</key>
<param><key>id</key><value>lora_sdr_gray_enc_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_dec</key>
<param><key>id</key><value>lora_sdr_hamming_dec_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_enc</key>
<param><key>id</key><value>lora_sdr_hamming_enc_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_header</key>
<param><key>id</key><value>lora_sdr_header_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
</block>
<block>
<key>lora_sdr_header_decoder</key>
<param><key>id</key><value>lora_sdr_header_decoder_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
</block>
<block>
<key>lora_sdr_interleaver</key>
<param><key>id</key><value>lora_sdr_interleaver_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_modulate</key>
<param><key>id</key><value>lora_sdr_modulate_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>minoutbuf</key><value>10000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_whitening</key>
<param><key>id</key><value>lora_sdr_whitening_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Modulacao"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Parte real do sinal modulado"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Parte imaginaria do sinal modulado"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Magnitude modulacao"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_imag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>strobe</source_key><sink_key>ref</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lora_sdr_whitening_0</sink_block_id><source_key>strobe</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_add_crc_0</source_block_id><sink_block_id>lora_sdr_hamming_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_deinterleaver_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_dewhitening_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_fft_demod_0</source_block_id><sink_block_id>lora_sdr_gray_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_decode_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_enc_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_enc_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CRC</source_key><sink_key>crc</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>err</source_key><sink_key>err</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_interleaver_0</source_block_id><sink_block_id>lora_sdr_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_complex_to_imag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_whitening_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

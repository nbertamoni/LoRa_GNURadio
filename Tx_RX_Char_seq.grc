<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_RX</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cr</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_period</value></param>
<param><key>value</key><value>600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>has_crc</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>impl_head</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_frame</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pay_len</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0_1</value></param>
<param><key>dist</key><value>blocks.STROBE_UNIFORM</value></param>
<param><key>mean</key><value>frame_period</value></param>
<param><key>msg</key><value>pmt.intern('')</value></param>
<param><key>std</key><value>200</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>taps</key><value>-0.128616616593872,	-0.212206590789194,	-0.180063263231421,	3.89817183251938e-17	,0.300105438719035	,0.636619772367581	,0.900316316157106,	1	,0.900316316157106,	0.636619772367581,	0.300105438719035,	3.89817183251938e-17,	-0.180063263231421,	-0.212206590789194,	-0.128616616593872</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lora_sdr_add_crc</key>
<param><key>id</key><value>lora_sdr_add_crc_0</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
</block>
<block>
<key>lora_sdr_crc_verif</key>
<param><key>id</key><value>lora_sdr_crc_verif_0</value></param>
</block>
<block>
<key>lora_sdr_data_source</key>
<param><key>id</key><value>lora_sdr_data_source_0</value></param>
<param><key>n_frames</key><value>n_frame</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
</block>
<block>
<key>lora_sdr_deinterleaver</key>
<param><key>id</key><value>lora_sdr_deinterleaver_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_dewhitening</key>
<param><key>id</key><value>lora_sdr_dewhitening_0</value></param>
</block>
<block>
<key>lora_sdr_err_measures</key>
<param><key>id</key><value>lora_sdr_err_measures_0</value></param>
</block>
<block>
<key>lora_sdr_fft_demod</key>
<param><key>id</key><value>lora_sdr_fft_demod_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_frame_sync</key>
<param><key>id</key><value>lora_sdr_frame_sync_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_gray_decode</key>
<param><key>id</key><value>lora_sdr_gray_decode_0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_gray_enc</key>
<param><key>id</key><value>lora_sdr_gray_enc_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_dec</key>
<param><key>id</key><value>lora_sdr_hamming_dec_0</value></param>
</block>
<block>
<key>lora_sdr_hamming_enc</key>
<param><key>id</key><value>lora_sdr_hamming_enc_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_header</key>
<param><key>id</key><value>lora_sdr_header_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
</block>
<block>
<key>lora_sdr_header_decoder</key>
<param><key>id</key><value>lora_sdr_header_decoder_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>has_crc</key><value>has_crc</value></param>
<param><key>impl_head</key><value>impl_head</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
</block>
<block>
<key>lora_sdr_interleaver</key>
<param><key>id</key><value>lora_sdr_interleaver_0</value></param>
<param><key>cr</key><value>cr</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_modulate</key>
<param><key>id</key><value>lora_sdr_modulate_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>minoutbuf</key><value>10000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_whitening</key>
<param><key>id</key><value>lora_sdr_whitening_0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>reparar que o err measures não está sincronizado ainda</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_random_0_1</source_block_id><sink_block_id>lora_sdr_data_source_0</sink_block_id><source_key>strobe</source_key><sink_key>trigg</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_add_crc_0</source_block_id><sink_block_id>lora_sdr_hamming_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>blocks_message_strobe_random_0_1</sink_block_id><source_key>msg</source_key><sink_key>set_msg</sink_key></connection>
<connection><source_block_id>lora_sdr_crc_verif_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_err_measures_0</sink_block_id><source_key>msg</source_key><sink_key>ref</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_data_source_0</source_block_id><sink_block_id>lora_sdr_whitening_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>lora_sdr_deinterleaver_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_dewhitening_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_fft_demod_0</source_block_id><sink_block_id>lora_sdr_gray_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>new_frame</source_key><sink_key>new_frame</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_sync_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_decode_0</source_block_id><sink_block_id>lora_sdr_modulate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_gray_enc_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_dec_0</source_block_id><sink_block_id>lora_sdr_header_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_hamming_enc_0</source_block_id><sink_block_id>lora_sdr_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_0</source_block_id><sink_block_id>lora_sdr_add_crc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_deinterleaver_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_fft_demod_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_hamming_dec_0</sink_block_id><source_key>CR</source_key><sink_key>CR</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>CRC</source_key><sink_key>CRC</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>CRC</source_key><sink_key>crc</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>err</source_key><sink_key>err</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_crc_verif_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_dewhitening_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_header_decoder_0</source_block_id><sink_block_id>lora_sdr_frame_sync_0</sink_block_id><source_key>pay_len</source_key><sink_key>pay_len</sink_key></connection>
<connection><source_block_id>lora_sdr_interleaver_0</source_block_id><sink_block_id>lora_sdr_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_modulate_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_whitening_0</source_block_id><sink_block_id>lora_sdr_header_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
